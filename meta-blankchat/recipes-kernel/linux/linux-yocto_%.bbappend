FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://hardening.cfg"
