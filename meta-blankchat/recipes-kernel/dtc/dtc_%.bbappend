BUILD_CFLAGS:append = " -Wno-error=discarded-qualifiers"
CFLAGS:append = " -Wno-error=discarded-qualifiers"
